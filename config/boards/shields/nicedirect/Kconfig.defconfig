## config/boards/shields/nicematrix/Kconfig.defconfig
```kconfig
if SHIELD_NICEMATRIX

config ZMK_KEYBOARD_NAME
    default "nicematrix"
    
endif
```
